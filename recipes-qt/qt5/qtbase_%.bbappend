FILESEXTRAPATHS:prepend := "${THISDIR}"
PACKAGECONFIG:append = " gles2"